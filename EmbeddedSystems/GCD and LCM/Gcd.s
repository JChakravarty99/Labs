	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=N1
	LDR R1,=N2
	LDRB R2,[R0]
	LDRB R3,[R1]
BACK 
	CMP R2,R3
	BEQ EXIT
	BCS DOWN
	SUB R3,R2
	B BACK
DOWN 
	SUB R2,R3
	B BACK
EXIT 
	LDR R0,=DST
	STRB R2,[R0]
	
STOP 
	B STOP
N1 DCD 48
N2 DCD 36
	AREA mydata,DATA,READWRITE
DST DCD 0
	END
	
	