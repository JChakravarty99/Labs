	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=N1
	LDR R1,=N2
	LDRB R2,[R0]
	LDRB R3,[R1]
	MOV R4,#0
	MOV R5,R2
	MOV R6,R3
BACK CMP R2,R3
	BEQ EXIT
	BCS DOWN
	SUB R3,R2
	B BACK
DOWN SUB R2,R3
	B BACK
EXIT 
	MUL R7,R5,R6
UP	CMP R7,R2
	BCC store
	SUB R7,R2
	ADD R4,#1
	B UP
store LDR R8,=DST
	STR R4,[R8]
	
STOP B STOP
N1 DCD 2
N2 DCD 3
	AREA mydata,DATA,READWRITE
DST DCD 0
	END
	
	